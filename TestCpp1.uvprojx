# Keil uVision project TestCpp1.uvprojx, settings and files
target TM4C123G (6190000::V6.19::ARMCLANG)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestCpp1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Scr
    ./: main.cpp Clock.h Clock.cpp UART.h UART.cpp GPIO.h GPIO.cpp PWM.h PWM.cpp
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
